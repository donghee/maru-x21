# Repository donghee/maru-x21

File README.md:

# MARU X21

Pixhawk compatible autopilot based from AUAV X2.1

PCB assembly and program bootloader

Case assembly

Maiden flight

----

# Secification

FMU processor: stm32f427vit6
 - 32-bit ARM Cortex M4 core with FPU
 - 180 Mhz/256 KB RAM/2 MB Flash

IO processor: stm32f100c8t6
 - 32-bit ARM Cortex M3 core
 - 24 MHz/8 KB RAM/64 KB Flash

IMU sensors
 - icm-20602 6 axis accel and gyro (main imu)
 - mpu-9250 9 axis accel and gyro and mag
 - ms5611 barometer

Interfaces
 - 5x UARTs
 - 1x CANbus
 - RC Interfaces: PPM/SBUS/DSM/RSSI Input
 - I2C
 - SPI

Power Input
 - 4.8v~5.4v

## KiCad design maru-x21.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C11, C20, C21, C28, C30, C31, C32, C33, C34, C35, C36, C38, C39, C40, C41, C43, C49, C51, C52, C54, C57, C58, C59, C60, C61: 100nF; C_0402
C8, C9, C53: 10uF 16V; C_0805
C10: 220uF; C_1210
C12, C13, C42, C48, C50: 2u2F; C_0603
C14, C15, C16, C17: 2u2F 10V; C_0805
C18, C19, C44, C45: 8pF; C_0402
C22, C23, C24, C25, C26: 10uF 10V; C_0805
C27, C29, C47: 1uF; C_0603
C46: 470nF; C_0603
C55, C56: 47uF 16V; C_0805
D1, D4: RED; LED_0603
D2: BAS70-02V; D_SOD-523
D3: GREEN; LED_0603
D5: BLUE; LED_0603
D6: 1N4148WT; D_SOD-523
D7: PMEG3002; D_SOD-323F
J1, J2: ARM Cortex JTAG 6p; Tag-Connect_TC2030-IDC-NL-NOHOLE
J3: BRICK; Pin_Header_Straight_1x04_Pitch2.54mm
J4: Micro_SD_Card; DM3CS-SF
J5: IO_CHANNELS; Pin_Header_Straight_1x08_Pitch2.54mm
J6: VDD_SERVO; Pin_Header_Straight_1x08_Pitch2.54mm
J7: SERVO_GND; Pin_Header_Straight_1x08_Pitch2.54mm
J8: SAFETY; Pin_Header_Straight_1x03_Pitch2.54mm
J9: CH1-3; Pin_Header_Straight_1x04_Pitch2.54mm
J10: CH4-6; Pin_Header_Straight_1x04_Pitch2.54mm
J11: BUZZ; Pin_Header_Straight_1x03_Pitch2.54mm
J12: AIR; Pin_Header_Straight_1x03_Pitch2.54mm
J13: AUX-ADC1; Pin_Header_Straight_1x02_Pitch2.54mm
J14: AUX-ADC2; Pin_Header_Straight_1x02_Pitch2.54mm
J15: SIPI; Pin_Header_Straight_1x03_Pitch2.54mm
J16: SPEKT; Pin_Header_Straight_1x03_Pitch2.54mm
J17: SERIAL1; JST_GH_SM06B-GHS-TB_06x1.25mm_Angled
J18: TELEM2; Pin_Header_Straight_1x06_Pitch2.54mm
J19: CAN; JST_GH_SM04B-GHS-TB_04x1.25mm_Angled
J20: SERIAL4; Pin_Header_Straight_1x04_Pitch2.54mm
J21: SERIAL5; Pin_Header_Straight_1x04_Pitch2.54mm
J22: GPS/I2C; JST_GH_SM06B-GHS-TB_06x1.25mm_Angled
J23: SORI; Pin_Header_Straight_1x03_Pitch2.54mm
LOGO1: OPEN_HARDWARE_1; OSHW-Logo_5.7x6mm_SilkScreen
M1, M2, M3, M4: MOUNTING-HOLE; MountingHole_3.2mm_M3
P1: USB_OTG; Connector_USB_Micro_B_SMD
Q1: SI3493BDV; TSOP-6_1.65x3.05mm_Pitch0.95mm
Q2: DMG1012UW; SOT-323_SC-70
R1, R4, R34, R35, R38: 470; R_0402_NoSilk
R2, R8, R9, R12, R13, R14, R33, R45, R46, R48, R49, R50, R51, R52, R64: 10K; R_0402_NoSilk
R5: 200 1%; R_0402_NoSilk
R6: 1K 1%; R_0402_NoSilk
R7, R16, R17, R18, R19, R20: 100K; R_0402_NoSilk
R10, R11: 470K; R_0402_NoSilk
R15, R29, R30: 1K; R_0402_NoSilk
R21: DNP; R_0805
R22, R23: 220; R_0805
R24: 2K7; R_0402_NoSilk
R25, R26: 1M; R_0402_NoSilk
R27, R28: 22; R_0402_NoSilk
R31, R32, R39, R40, R41, R42, R43, R44, R53, R54, R55, R56, R57, R58, R59, R60, R61, R65, R68, R69, R70, R71, R72, R73: 220; R_0402_NoSilk
R36: 47; R_0402_NoSilk
R37, R66, R67: 1K5; R_0402_NoSilk
R47: 10; R_0402_NoSilk
R62: 100; R_0402_NoSilk
R63: 120; R_0402_NoSilk
RN1: 220; R_Cat16-8
U1: LTC4415; MSOP-16-1EP_3x4mm_Pitch0.5mm
U2: TPS2062; MSOP-8-1EP_3x3mm_Pitch0.65mm
U3: STM32F427VIT6; LQFP-100-L_14x14mm_Pitch0.5mm
U4, U5, U6, U7: LP5907; SOT-23-5
U8: FM25V02A-G; SOIC-8_3.9x4.9mm_Pitch1.27mm
U9: DORCA30; QFN-24_4x4mm_Pitch0.5mm
U10: MS5611-01BA03; ms5611-01ba03
U11: STM32F100C8T6; LQFP-48-L_7x7mm_Pitch0.5mm
U12: ICM-20602; LGA-16_3x3mm_Pitch0.5mm; digikey# 1428-1060-1-ND
U13: TJA1051TK/3; DFN-8-1EP_3x3mm_Pitch0.65mm; digikey# 568-8686-1-ND
U14: 74LVC2G240; TSSOP-8_3x3mm_Pitch0.65mm
U15: MPU-9250; QFN-24_3x3mm_Pitch0.4mm_large_pads; digikey# 1428-1019-1-ND
X1, X2: 24MHz; ABM8

Connections:
/20608_CS: U3.9 (PC15), U12.6 (INT); also elsewhere on the board
/20608_DRDY: U3.8 (PC14), U12.5 (~CS); also elsewhere on the board
/ALARM: R45.2, U3.77 (PA15)
/BARO_CS: U3.88 (PD7), U10.5 (CSB)
/BATT_CURR_SENS: R30.2, U3.26 (PA3)
/BATT_VOLT_SENS: R29.2, U3.25 (PA2)
/FLASH_CS: U3.57 (PD10), U8.1 (CS)
/FLASH_MISO: U3.53 (PB14), U8.2 (IO1_DO)
/FLASH_MOSI: U3.54 (PB15), U8.5 (IO0_DI)
/FLASH_SCK: U3.52 (PB13), U8.6 (CLK)
/FMU_AUX_ADC1: R51.2, U3.18 (PC3)
/FMU_AUX_ADC2: R52.2, U3.33 (PC4)
/FMU_CAN1_RX: U3.81 (PD0), U13.4 (RXD)
/FMU_CAN1_TX: U3.82 (PD1), U13.1 (TXD)
/FMU_CH1: R39.2, U3.45 (PE14)
/FMU_CH2: R40.2, U3.44 (PE13)
/FMU_CH3: R41.2, U3.42 (PE11)
/FMU_CH4: R42.2, U3.40 (PE9)
/FMU_CH5: R43.2, U3.60 (PD13)
/FMU_CH6: R44.2, U3.61 (PD14)
/FMU_I2C1_SCL: J22.4, R67.1, U3.95 (PB8)
/FMU_I2C1_SDA: J22.5, R66.1, U3.96 (PB9)
/FMU_RESET: C11.1, J2.3, U3.14 (NRST)
/FMU_SWCLK: J2.4, U3.76 (PA14)
/FMU_SWDIO: J2.2, U3.72 (PA13)
/FMU_UART2_CTS: R55.2, U3.84 (PD3)
/FMU_UART2_RTS: R54.2, U3.85 (PD4)
/FMU_UART2_RX: R56.2, U3.87 (PD6)
/FMU_UART2_TX: R57.2, U3.86 (PD5)
/FMU_UART3_CTS: R59.2, U3.58 (PD11)
/FMU_UART3_RTS: R58.2, U3.59 (PD12)
/FMU_UART3_RX: R60.2, U3.56 (PD9)
/FMU_UART3_TX: R61.2, U3.55 (PD8)
/FMU_UART4_RX: R72.2, U3.24 (PA1)
/FMU_UART4_TX: R73.2, U3.23 (PA0)
/FMU_UART7_RX: R70.2, U3.38 (PE7)
/FMU_UART7_TX: R71.2, U3.39 (PE8)
/FMU_UART8_RX: R68.2, U3.97 (PE0)
/FMU_UART8_TX: R69.2, U3.98 (PE1)
/FMU_VBAT: C10.2, D2.1 (K), U3.6 (VBAT)
/FMU_VDD_3V3: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C20.1, C23.1, C25.1, C28.1, C29.1, D1.2 (A), J2.1, J4.4 (VDD), R2.1, R7.1, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R23.1, R66.2, R67.2, U3.11 (VDD), U3.19 (VDD), U3.21 (VREF+), U3.22 (VDDA), U3.28 (VDD), U3.50 (VDD), U3.75 (VDD), U3.100 (VDD), U6.5 (VOUT), U8.3 (IO2_WP), U8.7 (IO3_HOLD), U8.8 (VCC), U9.5 (VCC0), U13.5 (VIO)
/IO_CH1: RN1.16 (R1.2), U11.10 (PA0-WKUP)
/IO_CH2: RN1.15 (R2.2), U11.11 (PA1)
/IO_CH3: RN1.14 (R3.2), U11.45 (PB8)
/IO_CH4: RN1.13 (R4.2), U11.46 (PB9)
/IO_CH5: RN1.12 (R5.2), U11.16 (PA6)
/IO_CH6: RN1.11 (R6.2), U11.17 (PA7)
/IO_CH7: RN1.10 (R7.2), U11.18 (PB0)
/IO_CH8: RN1.9 (R8.2), U11.19 (PB1)
/IO_LED_BLUE: R35.2, U11.27 (PB14)
/IO_LED_RED: R34.2, U11.28 (PB15)
/IO_LED_SAFETY: R36.2, U11.26 (PB13)
/IO_RESET: C39.2, J1.3, U11.7 (NRST)
/IO_SWCLK: J1.4, U11.37 (PA14)
/IO_SWDIO: J1.2, U11.34 (PA13)
/IO_UART1_RX: R62.2, U11.31 (PA10)
/IO_UART1_TX: R1.2, U11.30 (PA9)
/IO_VDD_3V3: C24.1, C33.2, C34.2, C35.2, C36.2, C49.1, J1.1, J8.1, R22.1, R33.2, U5.5 (VOUT), U11.9 (VDDA), U11.24 (VDD), U11.36 (VDD), U11.48 (VDD), U14.8 (VCC)
/KILL: J11.1, U3.47 (PB10)
/MPU9250_CS: U3.17 (PC2), U15.22 (~CS)
/MPU9250_DRDY: U3.62 (PD15), U15.12 (INT)
/OTG_FS_N: R27.2, U3.70 (PA11)
/OTG_FS_P: R28.2, U3.71 (PA12)
/PPM_INPUT: R53.1, U11.29 (PA8), U14.2 (1A)
/PRESSURE_SENS: C41.1, R49.2, R50.2, U3.34 (PC5)
/RSSI_IN: R64.1, U11.15 (PA5), U11.33 (PA12)
/SAFETY: J8.3, R37.2, U11.41 (PB5)
/SBUS_INPUT: U11.22 (PB11), U14.6 (1Y)
/SBUS_OUTPUT: U11.21 (PB10), U14.5 (2A)
/SBUS_OUTPUT_EN: U11.40 (PB4), U14.7 (2~OE)
/SDIO_CK: J4.5 (CLK), U3.80 (PC12)
/SDIO_CMD: J4.3 (CMD), R18.1, U3.83 (PD2)
/SDIO_D0: J4.7 (DAT0), R19.1, U3.65 (PC8)
/SDIO_D1: J4.8 (DAT1), R20.1, U3.66 (PC9)
/SDIO_D2: J4.1 (DAT2), R16.1, U3.78 (PC10)
/SDIO_D3: J4.2 (DAT3/CD), R17.1, U3.79 (PC11)
/SERIAL_FMU_TO_IO: R32.2, U3.63 (PC6)
/SERIAL_IO_TO_FMU: R31.2, U3.64 (PC7)
/SPI_EXT_MISO: U3.4 (PE5), U9.23 (MISO)
/SPI_EXT_MOSI: U3.5 (PE6), U9.22 (MOSI)
/SPI_EXT_NSS: U3.3 (PE4), U9.19 (CSN0)
/SPI_EXT_SCK: U3.1 (PE2), U9.21 (SCK)
/SPI_INT_MISO: U3.31 (PA6), U10.6 (SDO), U12.4 (AD0/SDO), U15.9 (AD0/MISO); also elsewhere on the board
/SPI_INT_MOSI: U3.32 (PA7), U10.7 (SDI), U12.3 (SDA/SDI), U15.24 (SDA/MOSI); also elsewhere on the board
/SPI_INT_SCK: U3.30 (PA5), U10.8 (SCLK), U12.2 (SCL/SCLK), U15.23 (SCL/SCLK); also elsewhere on the board
/VBUS: C30.2, P1.1 (VCC), U1.7 (IN2), U1.8 (IN2), U3.68 (PA9)
/VBUS_5V_BRICK: C53.1, J3.1, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
/VBUS_VALID: R11.1, U1.11 (~STAT2), U3.15 (PC0)
/VDD_3V3_SENSORS: C21.1, C22.1, C38.1, C42.1, C43.1, C50.1, C51.1, R21.1, U4.5 (VOUT), U10.1 (VDD), U12.1 (VDDIO), U12.16 (VDD), U15.1 (RESV_VDDIO), U15.8 (VDDIO), U15.13 (VDD); also elsewhere on the board
/VDD_3V3_SENSORS_EN: U3.2 (PE3), U4.3 (EN)
/VDD_3V3_SPEKTRUM: C26.1, C47.1, J16.1, U7.5 (VOUT)
/VDD_3V3_SPEKTRUM_EN: U7.3 (EN), U11.2 (PC13)
/VDD_5V: C14.1, C15.1, C16.1, C17.1, C54.2, C55.2, C56.2, D4.2 (A), D5.2 (A), R10.2, R11.2, R12.2, R38.1, U1.9 (OUT2), U1.10 (OUT2), U1.15 (OUT1), U1.16 (OUT1), U2.2 (IN1), U4.1 (VIN), U5.1 (VIN), U5.3 (EN), U6.1 (VIN), U6.3 (EN), U7.1 (VIN)
/VDD_5V_PERIPH: C8.1, C40.1, C48.1, C57.1, C58.1, C59.1, C60.1, C61.1, J9.1, J12.2, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, R47.2, U2.7 (OUT1), U13.3 (VCC)
/VDD_5V_PERIPH_EN: R8.1, U2.3 (~EN1), U2.4 (~EN2), U3.67 (PA8)
/VDD_5V_PERIPH_OC: R7.2, U2.5 (~OC2), U2.8 (~OC1), U3.46 (PE15)
/VDD_5V_RC: C9.1, D7.2 (A), U2.6 (OUT2)
/VDD_5V_SENS: R9.1, R12.1, U3.29 (PA4)
/VDD_BRICK_VALID: R10.1, U1.14 (~STAT1), U3.91 (PB5)
/shield: P1.GND (shield), R24.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.2, C32.2, C33.1, C34.1, C35.1, C36.1, C38.2, C39.1, C40.2, C41.2, C42.2, C43.2, C44.1, C45.1, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.1, C53.2, C54.1, C55.1, C56.1, C57.2, C58.2, C59.2, C60.2, C61.2, D3.1 (K), J1.5, J2.5, J3.4, J4.6 (VSS), J4.9 (SHIELD), J7.1, J7.2, J7.3, J7.4, J7.5, J7.6, J7.7, J7.8, J10.1, J12.1, J13.1, J14.1, J15.1, J16.2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; also elsewhere on the board
unnamed: C12.1, U3.49 (VCAP_1)
unnamed: C13.1, U3.73 (VCAP_2)
unnamed: C18.2, U3.12 (PH0), X1.1
unnamed: C19.2, U3.13 (PH1), X1.3
unnamed: C27.1, U9.24 (VDD)
unnamed: C31.1, J3.2, R25.1, R29.1
unnamed: C32.1, J3.3, R26.1, R30.1
unnamed: C44.2, U11.5 (PD0), X2.1
unnamed: C45.2, U11.6 (PD1), X2.3
unnamed 110: C46.1, U12.14 (REGOUT); also elsewhere on the board
unnamed: C52.2, U15.10 (REGOUT)
unnamed: D1.1 (K), R4.2
unnamed: D2.2 (A), R15.1
unnamed: D3.2 (A), R38.2
unnamed: D4.1 (K), R34.1
unnamed: D5.1 (K), R35.1
unnamed: D6.1 (K), J11.2, R47.1
unnamed: D6.2 (A), J11.3, Q2.3 (D)
unnamed: D7.1 (K), J15.2
unnamed: J5.1, RN1.1 (R1.1)
unnamed: J5.2, RN1.2 (R2.1)
unnamed: J5.3, RN1.3 (R3.1)
unnamed: J5.4, RN1.4 (R4.1)
unnamed: J5.5, RN1.5 (R5.1)
unnamed: J5.6, RN1.6 (R6.1)
unnamed: J5.7, RN1.7 (R7.1)
unnamed: J5.8, RN1.8 (R8.1)
unnamed: J6.1, J6.2, J6.3, J6.4, J6.5, J6.6, J6.7, J6.8
unnamed: J8.2, R36.1
unnamed: J9.2, R41.1
unnamed: J9.3, R40.1
unnamed: J9.4, R39.1
unnamed: J10.2, R44.1
unnamed: J10.3, R43.1
unnamed: J10.4, R42.1
unnamed: J12.3, R49.1
unnamed: J13.2, R51.1
unnamed: J14.2, R52.1
unnamed: J15.3, R53.2
unnamed: J16.3, R62.1
unnamed: J17.2, R57.1
unnamed: J17.3, R56.1
unnamed: J17.4, R55.1
unnamed: J17.5, R54.1
unnamed: J18.2, R61.1
unnamed: J18.3, R60.1
unnamed: J18.4, R59.1
unnamed: J18.5, R58.1
unnamed: J19.2, R63.2, U13.6 (CANL)
unnamed: J19.3, R63.1, U13.7 (CANH)
unnamed: J20.2, R69.1
unnamed: J20.3, R68.1
unnamed: J21.2, R71.1
unnamed: J21.3, R70.1
unnamed: J22.2, R73.1
unnamed: J22.3, R72.1
unnamed: J23.3, R65.1
unnamed: P1.2 (D-), R27.1
unnamed: P1.3 (D+), R28.1
unnamed: Q1.4 (S), U1.1 (IN1), U1.2 (IN1), U1.3 (EN1)
unnamed: Q2.1 (G), R45.1, R46.1
unnamed: R1.1, U3.69 (PA10)
unnamed: R2.2, U3.41 (PE10)
unnamed: R4.1, U3.43 (PE12)
unnamed: R5.1, U1.4 (Clim1)
unnamed: R6.1, U1.5 (Clim2)
unnamed: R13.1, U3.37 (PB2)
unnamed: R14.2, U3.94 (BOOT0)
unnamed: R31.1, U11.12 (PA2)
unnamed: R32.1, U11.13 (PA3)
unnamed: R33.1, U11.38 (PA15)
unnamed: R48.2, U11.20 (PB2)
unnamed: R64.2, R65.2, U14.3 (2Y)

Notes on the sheet:
IMU
IO CHANNELS
CAN
http://www.nxp.com/documents/data_sheet/74LVC2G86.pdf
TODO: Testpoint
SPARE ADC
AUAV X2.1 http://autode.sk/2BT1NOc
https://github.com/mRoboticsIO/Hardware/blob/master/X2.1/Docs/mRo_X21_r2_drawings.pdf
TODO: CHECK VDD_SERVO_SENS
TODO: CHECK IO_POWER_BREATHING
HARDWARE BIT Pixhawk 1: PC14 Floating PC15 Floating Pixhawk 2: PC14 3.3v PC15 GND
https://github.com/PX4/Firmware/blob/master/src/drivers/boards/auav-x21/board_config.h
STM32F7x5
https://goo.gl/fLnw3r
DORCA-30 SPI SPI_EXT
SBUS INPUT
SPEKTRUM SATELLITE
SERIAL
POWER
FMU
OTHER PORTS
POWER IN
MPU9250 PCB Guide https://store.invensense.com/datasheets/invensense/Accelerometer_Gyroscope_Design_Guidelines.pdf
BATT_VOLT_SENS, BATT_CURR_SENS 순서 바뀜. IC20608 DRY, CS 라인 바뀜

Board: 4 copper layers, 51.0 x 31.5 mm, 189 parts (66 on the bottom side), 174 nets.

Other parts of the board:
U12#2: ICM-20602; LGA-16_3x3mm_Pitch0.5mm

Their connections:
/20608_CS: U12#2.6; also elsewhere on the board
/20608_DRDY: U12#2.5; also elsewhere on the board
/SPI_INT_MISO: U12#2.4; also elsewhere on the board
/SPI_INT_MOSI: U12#2.3; also elsewhere on the board
/SPI_INT_SCK: U12#2.2; also elsewhere on the board
/VDD_3V3_SENSORS: U12#2.1, U12#2.16; also elsewhere on the board
GND: U12#2.7, U12#2.8, U12#2.9, U12#2.10, U12#2.11, U12#2.12, U12#2.13, U12#2.15; also elsewhere on the board
unnamed 110: U12#2.14; also elsewhere on the board

File gerber/maru-x21_20180312_bom.xlsx:

MARU X21 ver 0.1 BOM 20180312
Item | Qty | Reference(s) | Reference(s) | Footprint | manf#
1 | 32 | C1, C2, C3, C4, C5, C6, C7, C11, C20, C21, C28, C30, C31, C32, C33, C34, C35, C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 | 100nF | swi_dipol:C_0402 | GCM155R71C104KA55D
2 | 3 | C8, C9, C53 | 10uF 16V | swi_dipol:C_0805 | C3216X5R1C106K160AA
3 | 1 | C10 | 220uF | Capacitors_SMD:C_1210 | CL32A227MQVNNNE
4 | 5 | C12, C13, C42, C48, C50 | 2u2F | swi_dipol:C_0603 | C1608X5R1C225K080AB
5 | 4 | C14, C15, C16, C17 | 2u2F 10V | swi_dipol:C_0805 | C2012X5R1A225K085AA
6 | 4 | C18, C19, C44, C45 | 8pF | swi_dipol:C_0402 | GRM1555C1E8R0CA01D
7 | 5 | C22, C23, C24, C25, C26 | 10uF 10V | swi_dipol:C_0805 | C2012X5R1A106K085AB
8 | 3 | C27, C29, C47 | 1uF | swi_dipol:C_0603 | C1608X5R1C105K080AA
9 | 1 | C46 | 470nF | swi_dipol:C_0603 | GRM188R71C474KA88D
10 | 2 | C55, C56 | 47uF 16V | swi_dipol:C_0805 | C2012X5R1A476M125AC, LMK212BBJ476MG-T
11 | 2 | D1, D4 | RED | LEDs:LED_0603
12 | 1 | D2 | BAS70-02V | Diodes_SMD:D_SOD-523 | BAS70-02V-V-G-08, BAS70KFILM
13 | 1 | D3 | GREEN | LEDs:LED_0603
14 | 1 | D5 | BLUE | LEDs:LED_0603
15 | 1 | D6 | 1N4148WT | Diodes_SMD:D_SOD-523 | 1N4148WT
16 | 1 | D7 | PMEG3002 | Diodes_SMD:D_SOD-323F | PMEG3002EJ,115
19 | 1 | J4 | Micro_SD_Card | swi_sdcard:DM3CS-SF | DM3CS-SF
32 | 1 | J17 | SERIAL1 | Connectors_JST:JST_GH_SM06B-GHS-TB_06x1.25mm_Angled | SM06B-GHS-TB(LF)(SN)
34 | 1 | J19 | CAN | Connectors_JST:JST_GH_SM04B-GHS-TB_04x1.25mm_Angled | SM04B-GHS-TB(LF)(SN)-
37 | 1 | J22 | GPS/I2C | Connectors_JST:JST_GH_SM06B-GHS-TB_06x1.25mm_Angled | SM06B-GHS-TB(LF)(SN)
41 | 1 | P1 | USB_OTG | pkl_connectors:Connector_USB_Micro_B_SMD | 10118192-0001LF
42 | 1 | Q1 | SI3493BDV | Housings_SSOP:TSOP-6_1.65x3.05mm_Pitch0.95mm | SI3493BDV-T1-E3
43 | 1 | Q2 | DMG1012UW | TO_SOT_Packages_SMD:SOT-323_SC-70 | DMG1012UW-7
44 | 5 | R1, R4, R34, R35, R38 | 470 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ471X
45 | 15 | R2, R8, R9, R12, R13, R14, R33, R45, R46, R48, R49, R50, R51, R52, R64 | 10K | swi_dipol:R_0402_NoSilk | RC1005J103CS
46 | 1 | R5 | 200 1% | swi_dipol:R_0402_NoSilk | ERJ-2RKF2000X
47 | 1 | R6 | 1K 1% | swi_dipol:R_0402_NoSilk | ERJ-2RKF1001X
48 | 6 | R7, R16, R17, R18, R19, R20 | 100K | swi_dipol:R_0402_NoSilk | ERJ-2GEJ104X
49 | 2 | R10, R11 | 470K | swi_dipol:R_0402_NoSilk | ERJ-2GEJ474X
50 | 3 | R15, R29, R30 | 1K | swi_dipol:R_0402_NoSilk | ERJ-2GEJ102X
51 | 1 | R21 | DNP | swi_dipol:R_0805 | -
52 | 2 | R22, R23 | 220 | swi_dipol:R_0805 | RC2012J221CS
53 | 1 | R24 | 2K7 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ272X
54 | 2 | R25, R26 | 1M | swi_dipol:R_0402_NoSilk | ERJ-2GEJ105X
55 | 2 | R27, R28 | 22 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ220X
56 | 24 | R31, R32, R39, R40, R41, R42, R43, R44, R53, R54, R55, R56, R57, R58, R59, R60,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 | 220 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ221X
57 | 1 | R36 | 47 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ470X
58 | 3 | R37, R66, R67 | 1K5 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ152X
59 | 1 | R47 | 10 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ100X
60 | 1 | R62 | 100 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ101X
61 | 1 | R63 | 120 | swi_dipol:R_0402_NoSilk | ERJ-2GEJ121X
62 | 1 | RN1 | 220 | Resistors_SMD:R_Cat16-8 | CAT16-221J8LF
63 | 1 | U1 | LTC4415 | Housings_SSOP:MSOP-16-1EP_3x4mm_Pitch0.5mm | LTC4415EMSE#PBF
64 | 1 | U2 | TPS2062 | Housings_SSOP:MSOP-8-1EP_3x3mm_Pitch0.65mm | TPS2062CDGNR
65 | 1 | U3 | STM32F427VIT6 | swi_housings_qfp:LQFP-100-L_14x14mm_Pitch0.5mm | STM32F427VIT6
66 | 4 | U4, U5, U6, U7 | LP5907 | TO_SOT_Packages_SMD:SOT-23-5 | LP5907QMFX-3.3Q1
67 | 1 | U8 | FM25V02A-G | Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm | FM25V02A-G
68 | 1 | U9 | DORCA30 | swi_housings_qfp:QFN-24_4x4mm_Pitch0.5mm
69 | 1 | U10 | MS5611-01BA03 | swi_sensors:ms5611-01ba03 | MS561101BA03-50
70 | 1 | U11 | STM32F100C8T6 | swi_housings_qfp:LQFP-48-L_7x7mm_Pitch0.5mm | STM32F100C8T6B
71 | 1 | U12 | ICM-20602 | swi_sensors:LGA-16_3x3mm_Pitch0.5mm | ICM-20602
72 | 1 | U13 | TJA1051TK/3 | Housings_DFN_QFN:DFN-8-1EP_3x3mm_Pitch0.65mm | TJA1051TK/3,118
73 | 1 | U14 | 74LVC2G240 | Housings_SSOP:TSSOP-8_3x3mm_Pitch0.65mm | 74LVC2G240DP,125
74 | 1 | U15 | MPU-9250 | swi_sensors:QFN-24_3x3mm_Pitch0.4mm_large_pads | MPU-9250
75 | 2 | X1, X2 | 24MHz | swi_misc:ABM8 | NX3225SA-24.000MHZ-STD-CSR-1

## Commit log

2018-07-22 Add schematic and board, bom files
2018-07-22 add working log
2018-07-22 Add PCB pdf file
2018-07-22 Add Case STL file
2018-07-22 Add PX4 board_config.h
2018-07-22 Add assembly and madien flight video
2018-09-07 Add specification
2019-11-20 Add Interactive BOM builder
2020-02-26 Added interactive html bom
2020-06-19 Add legend document
2020-07-14 Add bom
2020-07-14 Remove IntersactiveHtmlBom
